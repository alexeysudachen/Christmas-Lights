# Keil uVision project station1.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: station1
  c flags: Optim=3 OneElfS=1 wLevel=2
  c misc: --cpp11
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ./: main.cpp features.hxx cortex_m.hxx cortex_m0.hxx
  group system
    ./: startup_stm32f030x6.s system_stm32f0xx.c
